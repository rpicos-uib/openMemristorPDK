.subckt memristor_hfo2_al BE TE
.ends
