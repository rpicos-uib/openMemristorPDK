.subckt memristor_tio2_ti BE TE
.ends
