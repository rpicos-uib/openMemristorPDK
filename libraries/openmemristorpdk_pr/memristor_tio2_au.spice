.subckt memristor_tio2_au BE TE
.ends
